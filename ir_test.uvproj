# Keil uVision project ir_test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ING91600 INGCHIPS
  cpu: CLOCK(128000000) CPUTYPE("Cortex-M4") FPU2 ELITTLE IROM(0x2000000-0x2200000) IRAM(0x20000000-0x20008000)
  output: ir_test +hex
  AfterMake: fromelf.exe --bin -o ir_test.bin ./output/ir_test.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: ../../../Users/zb/AppData/Roaming/Local/Program/ING_SDK/sdk/bundles/typical/inc;../../../Users/zb/AppData/Roaming/Local/Program/ING_SDK/sdk/bundles/typical/inc/os;../../../Users/zb/AppData/Roaming/Local/Program/ING_SDK/sdk/src/BSP;../../../Users/zb/AppData/Roaming/Local/Program/ING_SDK/sdk/src/FWlib;../../../Users/zb/AppData/Roaming/Local/Program/ING_SDK/sdk/src/StartUP/ing916;../../../Users/zb/AppData/Roaming/Local/Program/ING_SDK/sdk/src/Tools;../../../Users/zb/AppData/Roaming/Local/Program/ING_SDK/sdk/src
  library: MicroLIB
  memory RVCT4: ROM 33705984 size -31592448
  memory RVCT9: RAM 0 size 32768
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing91600.s
    ../../../Users/zb/AppData/Roaming/Local/Program/ING_SDK/sdk/bundles/typical/ING9168xx/: symdefs.m
  group FWlib
    ../../../Users/zb/AppData/Roaming/Local/Program/ING_SDK/sdk/src/FWlib/: peripheral_uart.c peripheral_pinctrl.c peripheral_sysctrl.c peripheral_timer.c
  group Tools
    ../../../Users/zb/AppData/Roaming/Local/Program/ING_SDK/sdk/src/Tools/: trace.c
