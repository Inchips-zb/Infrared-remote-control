# Keil uVision project ir_test.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ING91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff) CPUTYPE("Cortex-M4") FPU2 CLOCK(12800000) ELITTLE
  output: ir_test +hex
  AfterMake: fromelf.exe --bin -o ir_test.bin ./output/ir_test.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: .\src\key_board;../../../Users/zb/AppData/Roaming/Local/Program/ING_SDK/sdk/bundles/typical/inc;../../../Users/zb/AppData/Roaming/Local/Program/ING_SDK/sdk/bundles/typical/inc/os;../../../Users/zb/AppData/Roaming/Local/Program/ING_SDK/sdk/src/BSP;../../../Users/zb/AppData/Roaming/Local/Program/ING_SDK/sdk/src/FWlib;../../../Users/zb/AppData/Roaming/Local/Program/ING_SDK/sdk/src/StartUP/ing916;../../../Users/zb/AppData/Roaming/Local/Program/ING_SDK/sdk/src/Tools;../../../Users/zb/AppData/Roaming/Local/Program/ING_SDK/sdk/src
  library: MicroLIB
  memory RVCT4: ROM 0x2025000 size 0xfe1df000
  memory RVCT9: RAM 0x20005838 size 0x27c8
  group APP
    ./src/: main.c profile.c user_ir_remote.c
  group StartUP
    ./src/: startup_ing91600.s
    ../../../Users/zb/AppData/Roaming/Local/Program/ING_SDK/sdk/bundles/typical/ING9168xx/: symdefs.m
  group FWlib
    ../../../Users/zb/AppData/Roaming/Local/Program/ING_SDK/sdk/src/FWlib/: peripheral_uart.c peripheral_pinctrl.c peripheral_sysctrl.c peripheral_timer.c
    D:/Users/zb/AppData/Roaming/Local/Program/ING_SDK/sdk/src/FWlib/: peripheral_ir.c peripheral_gpio.c peripheral_adc.c peripheral_dma.c
  group Tools
    ../../../Users/zb/AppData/Roaming/Local/Program/ING_SDK/sdk/src/Tools/: trace.c
  group key_board
    ./src/key_board/: key_board.c key_board_sample.c
software components: CMSIS:CORE 4.3.0
